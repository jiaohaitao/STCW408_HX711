# Keil uVision project STC15W408AS.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: STC15W408AS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STC15W408AS.c ShuMaShow.c
