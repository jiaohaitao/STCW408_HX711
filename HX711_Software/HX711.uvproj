# Keil uVision project HX711.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: HX711
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: multi_button.c ShuMaShow.c STC15W408AS.c uart.c led.c hx711.c
